# Keil uVision project Deneme_2.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Deneme_2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\FreeRTOS Workspace\Include;..\..\FreeRTOS Workspace\Portable\GCC\ARM_CM4F;..\..\FreeRTOS Workspace\Portable\MemMang;..\..\FreeRTOS Workspace
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c Req.h RCC.c GPIO.c Delay.c USART.c
  group FreeRTOS
    ../../FreeRTOS Workspace/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group ARM_CM4F
    ../../FreeRTOS Workspace/Portable/GCC/ARM_CM4F/: port.c
  group MemMang
    ../../FreeRTOS Workspace/Portable/MemMang/: heap_4.c
software components: CMSIS:CORE 6.1.0, Device:Startup 2.6.3
